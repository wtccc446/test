# Keil uVision project Star_Light.uvprojx, settings and files
target Star_Lights_NET (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Star_Lights_V01_NET +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./Objects/Star_Lights_V01_NET.bin ./Objects/Star_Lights_V01_NET.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,STDLib,W5500_COMMAND
  c include: ..\BSP;..\Command;..\HWDriver;..\Core;..\User;..\StdLib\inc;..\BSP_W5500
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group BSP
    ../BSP/: AD717X.c AD5663.c AD7175_DMM.c AD7175_IMPD.c AD9833.c RelayControl.c TestControl.c EXT_AD5663.c hdc2010.c SHT85.c TCA9548.c CAT9555.c TMP117.c HDC3021.c ADS8320.c
  group Command
    ../Command/: AD5663_Cmd.c AD7175_DMM_Cmd.c AD7175_IMPD_Cmd.c AD9833_Cmd.c Cmd_Support.c I2C_Cmd.c Eeprom_Cmd.c Interface_Cmd.c Messageout.c SPI_Cmd.c TestControl_Cmd.c RelayControl_Cmd.c EXT_AD5663_Cmd.c hdc2010_Cmd.c SHT85_Cmd.c TCA9548_Cmd.c hdc3021_Cmd.c
  group STDLIB
    ../StdLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HWDriver
    ../HWDriver/: Delay.c I2C_Driver.c SPI_Driver.c Timer.c Usart.c GPIO.c
  group User
    ../User/: main.c stm32f10x_it.c system_stm32f10x.c Fixture_Type1.c
  group Core
    ../Core/: core_cm3.c startup_stm32f10x_hd.s
  group BSP_W5500
    ../BSP_W5500/: socket.c w5500.c w5500_interface.c
target Star_Lights_UART (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: Enso_Star_Lights_V2_UART +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,STDLib,UART_COMMAND
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.2.0
